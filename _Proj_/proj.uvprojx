# Keil uVision project proj.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MKL02Z32xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.13.0
  cpu: IRAM(0x1FFFFC00,0x00001000) IROM(0x00000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: proj +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\User;..\Driver;..\Startup
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x1ffffc00 size 0x1000
  group User
    ../User/: main.c share.c
  group Driver
    ../Driver/: delay.c kl02z_it.c kl02z_tpm.c kl02z_uart.c systeminfo.c tpm.h
  group Startup
    ../Startup/: MKL02Z4.h startup_MKL02Z4.s system_MKL02Z4.c system_MKL02Z4.h
